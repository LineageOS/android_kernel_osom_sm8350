## drivers/input/fingerprint/betterlife_fp/Kconfig
```kconfig
config BETTERLIFE_FINGERPRINT
    bool "betterlife Fingerprint"
	default y
	---help---
	betterlife fingerprint.
```
